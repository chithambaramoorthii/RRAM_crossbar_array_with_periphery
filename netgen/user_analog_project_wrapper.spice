* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130B

.subckt sky130_fd_pr__nfet_g5v0d10v5_27DT82 a_n345_n100# a_29_n126# a_n129_n126# a_287_n100#
+ a_187_n126# a_n287_n126# VSUBS
X0 a_129_n100# a_29_n126# a_n29_n100# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X1 a_n187_n100# a_n287_n126# a_n345_n100# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X2 a_n29_n100# a_n129_n126# a_n187_n100# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X3 a_287_n100# a_187_n126# a_129_n100# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
.ends

.subckt x1T1R_W1um_F4_layout BL WL sky130_fd_pr__nfet_g5v0d10v5_27DT82_0/VSUBS SL
Xsky130_fd_pr__nfet_g5v0d10v5_27DT82_0 SL WL WL m1_642_36# WL WL sky130_fd_pr__nfet_g5v0d10v5_27DT82_0/VSUBS
+ sky130_fd_pr__nfet_g5v0d10v5_27DT82
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_HDJJAB a_50_n42# a_n50_n68# a_n108_n42# w_n144_n104#
X0 a_50_n42# a_n50_n68# a_n108_n42# w_n144_n104# sky130_fd_pr__pfet_g5v0d10v5 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=500000u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_A3ZYGX a_50_n42# a_n50_n68# a_n108_n42# VSUBS
X0 a_50_n42# a_n50_n68# a_n108_n42# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=500000u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_RU632G a_60_n42# a_n60_n68# a_n118_n42# VSUBS
X0 a_60_n42# a_n60_n68# a_n118_n42# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=600000u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_DG94C2 w_n154_n146# a_n118_n84# a_60_n84# a_n60_n110#
X0 a_60_n84# a_n60_n110# a_n118_n84# w_n154_n146# sky130_fd_pr__pfet_g5v0d10v5 ad=2.436e+11p pd=2.26e+06u as=2.436e+11p ps=2.26e+06u w=840000u l=600000u
.ends

.subckt nand_D1_g5d10 VSS IN0 IN1 OUT VDD w_n34_n298# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_RU632G_0 sky130_fd_pr__nfet_g5v0d10v5_RU632G_0/a_60_n42#
+ IN0 VSS VSUBS sky130_fd_pr__nfet_g5v0d10v5_RU632G
Xsky130_fd_pr__nfet_g5v0d10v5_RU632G_1 OUT IN1 sky130_fd_pr__nfet_g5v0d10v5_RU632G_0/a_60_n42#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5_RU632G
Xsky130_fd_pr__pfet_g5v0d10v5_DG94C2_0 w_n34_n298# VDD OUT IN0 sky130_fd_pr__pfet_g5v0d10v5_DG94C2
Xsky130_fd_pr__pfet_g5v0d10v5_DG94C2_1 w_n34_n298# OUT VDD IN1 sky130_fd_pr__pfet_g5v0d10v5_DG94C2
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_CG94UW a_n108_n84# w_n144_n146# a_50_n84# a_n50_n110#
X0 a_50_n84# a_n50_n110# a_n108_n84# w_n144_n146# sky130_fd_pr__pfet_g5v0d10v5 ad=2.436e+11p pd=2.26e+06u as=2.436e+11p ps=2.26e+06u w=840000u l=500000u
.ends

.subckt and2_g5D10 OUT VDD nand_D1_g5d10_0/IN1 nand_D1_g5d10_0/IN0 nand_D1_g5d10_0/VSS
+ nand_D1_g5d10_0/VDD VSUBS
Xnand_D1_g5d10_0 nand_D1_g5d10_0/VSS nand_D1_g5d10_0/IN0 nand_D1_g5d10_0/IN1 nand_D1_g5d10_0/OUT
+ nand_D1_g5d10_0/VDD VDD VSUBS nand_D1_g5d10
Xsky130_fd_pr__nfet_g5v0d10v5_A3ZYGX_0 OUT nand_D1_g5d10_0/OUT nand_D1_g5d10_0/VSS
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5_A3ZYGX
Xsky130_fd_pr__pfet_g5v0d10v5_CG94UW_0 nand_D1_g5d10_0/VDD VDD OUT nand_D1_g5d10_0/OUT
+ sky130_fd_pr__pfet_g5v0d10v5_CG94UW
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_GK82RQ w_n144_n162# a_50_n100# a_n50_n126# a_n108_n100#
X0 a_50_n100# a_n50_n126# a_n108_n100# w_n144_n162# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt inverter_d5g10_W1um_L0p420 IN OUT w_n50_n420# VSS VDD VSUBS
Xsky130_fd_pr__pfet_g5v0d10v5_GK82RQ_0 w_n50_n420# OUT IN VDD sky130_fd_pr__pfet_g5v0d10v5_GK82RQ
Xsky130_fd_pr__nfet_g5v0d10v5_A3ZYGX_0 OUT IN VSS VSUBS sky130_fd_pr__nfet_g5v0d10v5_A3ZYGX
.ends

.subckt decoder_D1_g5d10 IN0 IN1 OUT0 OUT1 OUT2 OUT3 VSS VDD
Xand2_g5D10_0 OUT0 VDD inverter_d5g10_W1um_L0p420_0/OUT inverter_d5g10_W1um_L0p420_1/OUT
+ VSS VDD VSS and2_g5D10
Xand2_g5D10_1 OUT1 VDD IN0 inverter_d5g10_W1um_L0p420_0/OUT VSS VDD VSS and2_g5D10
Xand2_g5D10_2 OUT2 VDD IN1 inverter_d5g10_W1um_L0p420_1/OUT VSS VDD VSS and2_g5D10
Xand2_g5D10_3 OUT3 VDD IN0 IN1 VSS VDD VSS and2_g5D10
Xinverter_d5g10_W1um_L0p420_0 IN0 inverter_d5g10_W1um_L0p420_0/OUT VDD VSS VDD VSS
+ inverter_d5g10_W1um_L0p420
Xinverter_d5g10_W1um_L0p420_1 IN1 inverter_d5g10_W1um_L0p420_1/OUT VDD VSS VDD VSS
+ inverter_d5g10_W1um_L0p420
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_54DD5S w_n154_n146# a_n118_n84# a_60_n84# a_n60_n110#
X0 a_60_n84# a_n60_n110# a_n118_n84# w_n154_n146# sky130_fd_pr__pfet_g5v0d10v5 ad=2.436e+11p pd=2.26e+06u as=2.436e+11p ps=2.26e+06u w=840000u l=600000u
.ends

.subckt inverter_D1_g5v10 VDD GND IN OUT w_n98_n608# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_RU632G_0 OUT IN GND VSUBS sky130_fd_pr__nfet_g5v0d10v5_RU632G
Xsky130_fd_pr__pfet_g5v0d10v5_54DD5S_0 w_n98_n608# VDD OUT IN sky130_fd_pr__pfet_g5v0d10v5_54DD5S
.ends

.subckt decoder_with_pmos_D1_g5d10_tapped_2305 V1 V2 V3 V4 OUT IN0 IN1 VSS VDD
Xsky130_fd_pr__pfet_g5v0d10v5_HDJJAB_0 OUT inverter_D1_g5v10_2/OUT V2 VDD sky130_fd_pr__pfet_g5v0d10v5_HDJJAB
Xsky130_fd_pr__pfet_g5v0d10v5_HDJJAB_1 OUT inverter_D1_g5v10_1/OUT V1 VDD sky130_fd_pr__pfet_g5v0d10v5_HDJJAB
Xsky130_fd_pr__pfet_g5v0d10v5_HDJJAB_2 OUT inverter_D1_g5v10_0/OUT V4 VDD sky130_fd_pr__pfet_g5v0d10v5_HDJJAB
Xsky130_fd_pr__nfet_g5v0d10v5_A3ZYGX_0 OUT decoder_D1_g5d10_0/OUT2 V3 VSS sky130_fd_pr__nfet_g5v0d10v5_A3ZYGX
Xdecoder_D1_g5d10_0 IN0 IN1 inverter_D1_g5v10_1/IN inverter_D1_g5v10_2/IN decoder_D1_g5d10_0/OUT2
+ inverter_D1_g5v10_0/IN VSS VDD decoder_D1_g5d10
Xinverter_D1_g5v10_0 VDD VSS inverter_D1_g5v10_0/IN inverter_D1_g5v10_0/OUT VDD VSS
+ inverter_D1_g5v10
Xinverter_D1_g5v10_1 VDD VSS inverter_D1_g5v10_1/IN inverter_D1_g5v10_1/OUT VDD VSS
+ inverter_D1_g5v10
Xinverter_D1_g5v10_2 VDD VSS inverter_D1_g5v10_2/IN inverter_D1_g5v10_2/OUT VDD VSS
+ inverter_D1_g5v10
.ends

.subckt sky130_fd_pr__nfet_01v8_FNPZCM a_15_n42# a_n15_n68# a_n73_n42# VSUBS
X0 a_15_n42# a_n15_n68# a_n73_n42# VSUBS sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_pr__pfet_01v8_6PK3KM w_n109_n146# a_n73_n84# a_15_n84# a_n15_n110#
X0 a_15_n84# a_n15_n110# a_n73_n84# w_n109_n146# sky130_fd_pr__pfet_01v8 ad=2.436e+11p pd=2.26e+06u as=2.436e+11p ps=2.26e+06u w=840000u l=150000u
.ends

.subckt inv_D1_1v8 VDD VSS OUT IN
Xsky130_fd_pr__nfet_01v8_FNPZCM_0 OUT IN VSS VSS sky130_fd_pr__nfet_01v8_FNPZCM
Xsky130_fd_pr__pfet_01v8_6PK3KM_0 VDD VDD OUT IN sky130_fd_pr__pfet_01v8_6PK3KM
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_PDTLGW a_50_n100# a_n50_n126# a_n108_n100# VSUBS
X0 a_50_n100# a_n50_n126# a_n108_n100# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt VLS_g5D10_LV1v8_HV5V VDD_HIGH_5V VDD_LOW_1v8 DATA_IN_LV_1v8 DATA_OUT_HV_5V
+ VSS
Xsky130_fd_pr__pfet_g5v0d10v5_HDJJAB_0 VDD_HIGH_5V inverter_D1_g5v10_1/IN a_522_n46#
+ VDD_HIGH_5V sky130_fd_pr__pfet_g5v0d10v5_HDJJAB
Xsky130_fd_pr__pfet_g5v0d10v5_HDJJAB_1 inverter_D1_g5v10_1/IN a_522_n46# VDD_HIGH_5V
+ VDD_HIGH_5V sky130_fd_pr__pfet_g5v0d10v5_HDJJAB
Xinv_D1_1v8_0 VDD_LOW_1v8 VSS inv_D1_1v8_0/OUT DATA_IN_LV_1v8 inv_D1_1v8
Xsky130_fd_pr__nfet_g5v0d10v5_PDTLGW_1 inverter_D1_g5v10_1/IN inv_D1_1v8_0/OUT VSS
+ VSS sky130_fd_pr__nfet_g5v0d10v5_PDTLGW
Xsky130_fd_pr__nfet_g5v0d10v5_PDTLGW_0 VSS DATA_IN_LV_1v8 a_522_n46# VSS sky130_fd_pr__nfet_g5v0d10v5_PDTLGW
Xinverter_D1_g5v10_0 VDD_HIGH_5V VSS inverter_D1_g5v10_0/IN DATA_OUT_HV_5V VDD_HIGH_5V
+ VSS inverter_D1_g5v10
Xinverter_D1_g5v10_1 VDD_HIGH_5V VSS inverter_D1_g5v10_1/IN inverter_D1_g5v10_0/IN
+ VDD_HIGH_5V VSS inverter_D1_g5v10
.ends

.subckt VLS_1v8to5V_D1_And_VoltSelector_Layout V2 V3 V4 DATA_IN_LV_0 DATA_IN_LV_1
+ VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V V1 VDD_HIGH
+ VDD_LOW HV_OUT VSUBS
Xdecoder_with_pmos_D1_g5d10_tapped_2305_0 V1 V2 V3 V4 HV_OUT VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V VSUBS VDD_HIGH decoder_with_pmos_D1_g5d10_tapped_2305
XVLS_g5D10_LV1v8_HV5V_0 VDD_HIGH VDD_LOW DATA_IN_LV_0 VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ VSUBS VLS_g5D10_LV1v8_HV5V
XVLS_g5D10_LV1v8_HV5V_1 VDD_HIGH VDD_LOW DATA_IN_LV_1 VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ VSUBS VLS_g5D10_LV1v8_HV5V
.ends

.subckt x1T1R_LHS_05_06 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_W1um_F4_layout_0/BL
+ 1T1R_W1um_F4_layout_0/WL VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_W1um_F4_layout_0/SL VSUBS VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
X1T1R_W1um_F4_layout_0 1T1R_W1um_F4_layout_0/BL 1T1R_W1um_F4_layout_0/WL VSUBS 1T1R_W1um_F4_layout_0/SL
+ x1T1R_W1um_F4_layout
XVLS_1v8to5V_D1_And_VoltSelector_Layout_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_W1um_F4_layout_0/WL VSUBS
+ VLS_1v8to5V_D1_And_VoltSelector_Layout
.ends

.subckt x1T1R_LHS_05_06_15x1 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[2]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[5]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[3]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[13]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[0]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[6]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[10]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_0[12]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_0[4]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[1]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[11]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[14]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_0[8]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[7]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH VSUBS 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
X1T1R_LHS_05_06_0[0] 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[0]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[1] 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[1]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[2] 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[2]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[3] 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[3]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[4] 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[4]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[5] 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[5]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[6] 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[6]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[7] 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[7]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[8] 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[8]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[9] 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[10] 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[10]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[11] 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[11]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[12] 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[12]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[13] 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[13]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
X1T1R_LHS_05_06_0[14] 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_0[14]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL VSUBS 1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ x1T1R_LHS_05_06
.ends

.subckt x1 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/1T1R_W1um_F4_layout_0/WL VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VSUBS
X1T1R_LHS_05_06_15x1_0 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/SL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/BL
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VSUBS 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ x1T1R_LHS_05_06_15x1
XVLS_1v8to5V_D1_And_VoltSelector_Layout_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW VLS_1v8to5V_D1_And_VoltSelector_Layout_0/HV_OUT
+ VSUBS VLS_1v8to5V_D1_And_VoltSelector_Layout
.ends

.subckt x1T1R_topcell_04_06 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW 1T1R_W1um_F4_layout_0/SL VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/HV_OUT VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_W1um_F4_layout_0/WL VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/HV_OUT
+ 1T1R_W1um_F4_layout_0/BL VSUBS
X1T1R_W1um_F4_layout_0 1T1R_W1um_F4_layout_0/BL 1T1R_W1um_F4_layout_0/WL VSUBS 1T1R_W1um_F4_layout_0/SL
+ x1T1R_W1um_F4_layout
XVLS_1v8to5V_D1_And_VoltSelector_Layout_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW VLS_1v8to5V_D1_And_VoltSelector_Layout_0/HV_OUT
+ VSUBS VLS_1v8to5V_D1_And_VoltSelector_Layout
XVLS_1v8to5V_D1_And_VoltSelector_Layout_1 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1 VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW VLS_1v8to5V_D1_And_VoltSelector_Layout_1/HV_OUT
+ VSUBS VLS_1v8to5V_D1_And_VoltSelector_Layout
.ends

.subckt x1T1R_LHS_05_06_16x1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/1T1R_W1um_F4_layout_0/WL 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/HV_OUT 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/HV_OUT 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/1T1R_W1um_F4_layout_0/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/BL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/SL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/1T1R_W1um_F4_layout_0/WL
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/1T1R_W1um_F4_layout_0/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/1T1R_W1um_F4_layout_0/WL
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ VSUBS 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
X1_0 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/SL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/1T1R_W1um_F4_layout_0/WL
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/1T1R_W1um_F4_layout_0/WL 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/BL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/1T1R_W1um_F4_layout_0/WL 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ VSUBS x1
X1T1R_topcell_04_06_0 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/SL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/HV_OUT 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/HV_OUT 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/BL
+ VSUBS x1T1R_topcell_04_06
.ends

.subckt x1T1R_midcell_0506_16x1 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_W1um_F4_layout_12/WL
+ 1T1R_W1um_F4_layout_6/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_W1um_F4_layout_3/WL
+ 1T1R_W1um_F4_layout_2/WL 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_W1um_F4_layout_11/WL
+ 1T1R_W1um_F4_layout_14/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_W1um_F4_layout_8/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_W1um_F4_layout_9/SL 1T1R_W1um_F4_layout_7/WL 1T1R_W1um_F4_layout_5/WL 1T1R_W1um_F4_layout_1/WL
+ 1T1R_W1um_F4_layout_4/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_W1um_F4_layout_9/WL 1T1R_W1um_F4_layout_0/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_W1um_F4_layout_10/WL 1T1R_W1um_F4_layout_13/WL
X1T1R_W1um_F4_layout_0 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_0/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_10 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_10/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_1 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_1/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_11 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_11/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_2 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_2/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_12 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_12/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_3 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_3/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_13 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_13/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_4 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_4/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_5 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_5/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_14 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_14/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_6 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_6/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_7 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_7/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_8 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_8/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_W1um_F4_layout_9 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_9/WL VSUBS 1T1R_W1um_F4_layout_9/SL
+ x1T1R_W1um_F4_layout
X1T1R_topcell_04_06_0 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_W1um_F4_layout_9/SL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_W1um_F4_layout_9/SL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_W1um_F4_layout_9/BL 1T1R_W1um_F4_layout_9/BL VSUBS x1T1R_topcell_04_06
.ends

.subckt sky130_fd_pr__res_high_po_0p69_842TQM a_n69_n10432# a_n69_10000# VSUBS
X0 a_n69_n10432# a_n69_10000# VSUBS sky130_fd_pr__res_high_po w=690000u l=1e+08u
.ends

.subckt opamp in1 in2 out net1 out1 a_1352_1758# vdd vss
Xsky130_fd_pr__res_high_po_0p69_842TQM_0 vdd a_592_1044# vss sky130_fd_pr__res_high_po_0p69_842TQM
X0 vss a_592_1044# out vss sky130_fd_pr__nfet_01v8 ad=4.05333e+12p pd=1.6325e+07u as=1.35063e+13p ps=6.368e+07u w=3.141e+07u l=150000u
X1 out out1 vdd vdd sky130_fd_pr__pfet_01v8 ad=1.31922e+13p pd=6.366e+07u as=5.93362e+12p ps=2.7995e+07u w=3.141e+07u l=150000u
X2 out1 in2 a_78_82# vss sky130_fd_pr__nfet_01v8 ad=3.827e+11p pd=2.64e+06u as=4.6654e+12p ps=2.606e+07u w=890000u l=150000u
X3 vss a_592_1044# a_78_82# vss sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+07u l=150000u
X4 vss a_592_1044# a_592_1044# vss sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.35e+12p ps=1.094e+07u w=5e+06u l=150000u
X5 a_78_82# in1 net1 vss sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.827e+11p ps=2.64e+06u w=890000u l=150000u
X6 vdd net1 net1 vdd sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=2.15e+12p ps=1.086e+07u w=5e+06u l=150000u
X7 out1 net1 vdd vdd sky130_fd_pr__pfet_01v8 ad=2.1e+12p pd=1.084e+07u as=0p ps=0u w=5e+06u l=150000u
X8 out a_1352_1758# vss sky130_fd_pr__res_high_po w=690000u l=1e+08u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_HKHHPX w_n144_n162# a_50_n100# a_n50_n126# a_n108_n100#
X0 a_50_n100# a_n50_n126# a_n108_n100# w_n144_n162# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt HV_TG_GATE IN VDD_HIGH CTRL VSS OUT
Xsky130_fd_pr__pfet_g5v0d10v5_HKHHPX_0 VDD_HIGH OUT inverter_D1_g5v10_0/OUT IN sky130_fd_pr__pfet_g5v0d10v5_HKHHPX
Xsky130_fd_pr__nfet_g5v0d10v5_PDTLGW_0 OUT CTRL IN VSS sky130_fd_pr__nfet_g5v0d10v5_PDTLGW
Xinverter_D1_g5v10_0 VDD_HIGH VSS CTRL inverter_D1_g5v10_0/OUT VDD_HIGH VSS inverter_D1_g5v10
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_KJTLYG a_50_n100# a_n50_n126# a_n108_n100# VSUBS
X0 a_50_n100# a_n50_n126# a_n108_n100# VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt TG_2x1_MUX_HV IN1 IN0 VSS OUT S VDD
Xsky130_fd_pr__pfet_g5v0d10v5_GK82RQ_0 VDD OUT inverter_D1_g5v10_0/OUT IN1 sky130_fd_pr__pfet_g5v0d10v5_GK82RQ
Xsky130_fd_pr__pfet_g5v0d10v5_GK82RQ_1 VDD IN0 S OUT sky130_fd_pr__pfet_g5v0d10v5_GK82RQ
Xsky130_fd_pr__nfet_g5v0d10v5_KJTLYG_0 OUT S IN1 VSS sky130_fd_pr__nfet_g5v0d10v5_KJTLYG
Xsky130_fd_pr__nfet_g5v0d10v5_KJTLYG_1 IN0 inverter_D1_g5v10_0/OUT OUT VSS sky130_fd_pr__nfet_g5v0d10v5_KJTLYG
Xinverter_D1_g5v10_0 VDD VSS S inverter_D1_g5v10_0/OUT VDD VSS inverter_D1_g5v10
.ends

.subckt TG_4x1_MUX_HV IN0 IN1 VSS IN2 IN3 S0 S1 VDD_HIGH TG_2x1_MUX_HV_1/OUT TG_2x1_MUX_HV_0/S
XTG_2x1_MUX_HV_0 IN3 IN2 VSS TG_2x1_MUX_HV_1/IN1 TG_2x1_MUX_HV_0/S VDD_HIGH TG_2x1_MUX_HV
XTG_2x1_MUX_HV_1 TG_2x1_MUX_HV_1/IN1 TG_2x1_MUX_HV_2/OUT VSS TG_2x1_MUX_HV_1/OUT S1
+ VDD_HIGH TG_2x1_MUX_HV
XTG_2x1_MUX_HV_2 IN1 IN0 VSS TG_2x1_MUX_HV_2/OUT S0 VDD_HIGH TG_2x1_MUX_HV
.ends

.subckt TG_8x1_MUX_HV S2 OUT TG_4x1_MUX_HV_1/IN0 TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT
+ TG_4x1_MUX_HV_1/S1 TG_2x1_MUX_HV_0/IN0 TG_4x1_MUX_HV_1/S0 TG_4x1_MUX_HV_0/S1 TG_4x1_MUX_HV_0/S0
+ TG_4x1_MUX_HV_0/IN3 TG_4x1_MUX_HV_0/IN2 TG_4x1_MUX_HV_0/IN1 TG_4x1_MUX_HV_0/IN0
+ TG_2x1_MUX_HV_0/IN1 TG_4x1_MUX_HV_1/IN3 TG_2x1_MUX_HV_0/VDD VSS TG_4x1_MUX_HV_1/IN1
+ TG_4x1_MUX_HV_1/IN2
XTG_4x1_MUX_HV_0 TG_4x1_MUX_HV_0/IN0 TG_4x1_MUX_HV_0/IN1 VSS TG_4x1_MUX_HV_0/IN2 TG_4x1_MUX_HV_0/IN3
+ TG_4x1_MUX_HV_0/S0 TG_4x1_MUX_HV_0/S1 TG_2x1_MUX_HV_0/VDD TG_2x1_MUX_HV_0/IN0 TG_4x1_MUX_HV_0/S1
+ TG_4x1_MUX_HV
XTG_4x1_MUX_HV_1 TG_4x1_MUX_HV_1/IN0 TG_4x1_MUX_HV_1/IN1 VSS TG_4x1_MUX_HV_1/IN2 TG_4x1_MUX_HV_1/IN3
+ TG_4x1_MUX_HV_1/S0 TG_4x1_MUX_HV_1/S1 TG_2x1_MUX_HV_0/VDD TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT
+ TG_4x1_MUX_HV_1/S1 TG_4x1_MUX_HV
XTG_2x1_MUX_HV_0 TG_2x1_MUX_HV_0/IN1 TG_2x1_MUX_HV_0/IN0 VSS OUT S2 TG_2x1_MUX_HV_0/VDD
+ TG_2x1_MUX_HV
.ends

.subckt MuxingToPadWithOPAMP VDD_HIGH CTRL SL_TO_PAD1 OPAMP_IN1_TO_PAD2 OPAMP_IN2_TO_COMMON_PAD
+ OPAMP_PLUS_VDD OPAMP_OUT_TO_PAD3 OPAMP_GND TG_8x1_MUX_HV_0/S2 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN3
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN1 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN2 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN0
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S1 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S0 TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S1 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S0 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN3 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN2 TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/VDD
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN1 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN0
+ VSS
Xopamp_0 OPAMP_IN1_TO_PAD2 OPAMP_IN2_TO_COMMON_PAD OPAMP_OUT_TO_PAD3 opamp_0/net1
+ opamp_0/out1 OPAMP_GND OPAMP_PLUS_VDD VSS opamp
XHV_TG_GATE_0 HV_TG_GATE_0/IN VDD_HIGH CTRL VSS SL_TO_PAD1 HV_TG_GATE
XTG_8x1_MUX_HV_0 TG_8x1_MUX_HV_0/S2 HV_TG_GATE_0/IN TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN0
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S1
+ TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN0 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S0 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S1
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S0 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN3 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN2
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN1 TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN3 TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/VDD VSS TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN1
+ TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN2 TG_8x1_MUX_HV
.ends

.subckt reram OPAMP0_IN1_TO_PAD2 SL0_TO_PAD1 OPAMP1_IN2_TO_COMMON OPAMP1_IN1_TO_PAD2
+ SL1_TO_PAD1 MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S1 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S0 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN0 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ MuxingToPadWithOPAMP_0/OPAMP_PLUS_VDD 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_W1um_F4_layout_9/SL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ MuxingToPadWithOPAMP_0/OPAMP_GND 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/VDD
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S1 MuxingToPadWithOPAMP_0/CTRL
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 1T1R_midcell_0506_16x1_0[0]/1T1R_W1um_F4_layout_9/SL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S0 MuxingToPadWithOPAMP_1/OPAMP_PLUS_VDD
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN1 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ MuxingToPadWithOPAMP_0/VDD_HIGH 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN1 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN2 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/S2 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/SL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ MuxingToPadWithOPAMP_1/OPAMP_GND 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN2 1T1R_midcell_0506_16x1_0[13]/1T1R_W1um_F4_layout_9/SL
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH 1T1R_midcell_0506_16x1_0[7]/1T1R_W1um_F4_layout_9/SL
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ MuxingToPadWithOPAMP_1/CTRL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/S2 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ MuxingToPadWithOPAMP_1/OPAMP_OUT_TO_PAD3 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S1 MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S0 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ OPAMP0_IN2_TO_COMMON 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ MuxingToPadWithOPAMP_1/VDD_HIGH 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S1 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S0 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN0 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN3 1T1R_midcell_0506_16x1_0[11]/1T1R_W1um_F4_layout_9/SL
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_W1um_F4_layout_9/SL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/VDD 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/BL 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN3 1T1R_midcell_0506_16x1_0[14]/1T1R_W1um_F4_layout_9/SL
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ MuxingToPadWithOPAMP_0/OPAMP_OUT_TO_PAD3 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ VSUBS 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
X1T1R_LHS_05_06_16x1_0 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/BL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_1/DATA_OUT_HV_5V
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[10]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[6]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[7]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[8]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[5]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[1]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[13]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_LHS_05_06_16x1_0/1_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[2]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[9]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[0]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[3]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[4]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[11]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[12]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ VSUBS 1T1R_LHS_05_06_16x1_0/1_0/1T1R_LHS_05_06_15x1_0/1T1R_LHS_05_06_0[14]/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VLS_g5D10_LV1v8_HV5V_0/DATA_OUT_HV_5V
+ x1T1R_LHS_05_06_16x1
X1T1R_midcell_0506_16x1_0[0] 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[0]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[1] 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[1]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[2] 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[3] 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[4] 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[5] 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[6] 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[7] 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[7]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[8] 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[9] 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[10] 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[10]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[11] 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[11]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[12] 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[12]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[13] 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[13]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
X1T1R_midcell_0506_16x1_0[14] 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V4
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V3
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V2
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/V1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/DATA_IN_LV_0
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_12/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_6/WL
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V4
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V3
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V2
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/V1
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_3/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_2/WL
+ 1T1R_LHS_05_06_16x1_0/1T1R_topcell_04_06_0/1T1R_W1um_F4_layout_0/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_11/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_14/WL 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/VDD_LOW
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_8/WL 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_0/VDD_HIGH
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_7/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_5/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_1/WL
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_4/WL 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_0/WL
+ 1T1R_midcell_0506_16x1_0[14]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_0
+ VSUBS 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_10/WL 1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_13/WL
+ x1T1R_midcell_0506_16x1
XMuxingToPadWithOPAMP_0 MuxingToPadWithOPAMP_0/VDD_HIGH MuxingToPadWithOPAMP_0/CTRL
+ SL0_TO_PAD1 OPAMP0_IN1_TO_PAD2 OPAMP0_IN2_TO_COMMON MuxingToPadWithOPAMP_0/OPAMP_PLUS_VDD
+ MuxingToPadWithOPAMP_0/OPAMP_OUT_TO_PAD3 MuxingToPadWithOPAMP_0/OPAMP_GND MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/S2
+ 1T1R_midcell_0506_16x1_0[3]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[5]/1T1R_W1um_F4_layout_9/SL
+ 1T1R_midcell_0506_16x1_0[4]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[6]/1T1R_W1um_F4_layout_9/SL
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S1 MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S0
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1 MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S1
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S0 MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT
+ 1T1R_midcell_0506_16x1_0[2]/1T1R_W1um_F4_layout_9/SL 1T1R_midcell_0506_16x1_0[1]/1T1R_W1um_F4_layout_9/SL
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/VDD 1T1R_midcell_0506_16x1_0[0]/1T1R_W1um_F4_layout_9/SL
+ MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 MuxingToPadWithOPAMP_0/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN0
+ VSUBS MuxingToPadWithOPAMP
XMuxingToPadWithOPAMP_1 MuxingToPadWithOPAMP_1/VDD_HIGH MuxingToPadWithOPAMP_1/CTRL
+ SL1_TO_PAD1 OPAMP1_IN1_TO_PAD2 OPAMP1_IN2_TO_COMMON MuxingToPadWithOPAMP_1/OPAMP_PLUS_VDD
+ MuxingToPadWithOPAMP_1/OPAMP_OUT_TO_PAD3 MuxingToPadWithOPAMP_1/OPAMP_GND MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/S2
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN3 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN2 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/IN0
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S1 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/S0
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/S0 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_1/TG_2x1_MUX_HV_1/OUT
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN3 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN2
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/VDD MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN1
+ MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_4x1_MUX_HV_0/IN0 MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN0
+ VSUBS MuxingToPadWithOPAMP
.ends

.subckt user_analog_project_wrapper vssa1 vssa2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[1] wbs_adr_i[2] wbs_adr_i[3] wbs_adr_i[4]
+ wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0]
+ wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14] wbs_dat_i[15]
+ wbs_dat_i[16] wbs_dat_i[1] wbs_dat_i[2] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6]
+ wbs_dat_i[7] wbs_dat_i[8] wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11]
+ wbs_dat_o[12] wbs_dat_o[13] wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[1]
+ wbs_dat_o[2] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7] wbs_dat_o[8]
+ wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i wbs_we_i
+ wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_adr_i[18] wbs_dat_i[20] wbs_dat_i[21]
+ wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27]
+ wbs_dat_i[28] wbs_dat_i[29] wbs_adr_i[19] wbs_dat_i[30] wbs_dat_i[31] la_oenb[0]
+ wbs_adr_i[20] wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25]
+ wbs_adr_i[26] wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] la_oenb[1] wbs_adr_i[30]
+ wbs_adr_i[31] la_oenb[2] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19] la_oenb[3] wbs_dat_o[20]
+ wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26]
+ wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] la_oenb[4] wbs_dat_o[30] wbs_dat_o[31]
+ la_oenb[5] la_data_in[0] la_data_in[1] la_data_in[2] la_data_in[3] la_data_in[4]
+ la_data_in[5] la_data_out[0] la_data_out[1] la_data_out[2] la_data_out[3] la_data_out[4]
+ la_data_out[5] la_data_in[23] la_data_in[24] la_data_in[25] la_oenb[6] la_oenb[7]
+ la_oenb[8] la_oenb[9] la_data_in[26] la_data_in[11] la_data_in[12] la_data_in[13]
+ la_data_in[14] la_data_in[6] la_data_in[7] la_data_in[8] la_data_in[9] la_data_in[15]
+ la_data_out[10] la_data_out[11] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_in[16] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[10] la_data_out[6]
+ la_data_out[7] la_data_out[8] la_data_out[9] la_data_in[20] la_oenb[10] la_oenb[11]
+ la_oenb[12] la_oenb[13] la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18]
+ la_oenb[19] la_data_in[21] la_oenb[20] la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24]
+ la_oenb[25] la_data_in[22] la_data_in[39] la_oenb[45] la_data_in[40] la_data_out[26]
+ la_data_out[27] la_data_out[28] la_data_out[29] la_data_in[41] la_data_out[30] la_data_out[31]
+ la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35] la_data_out[36]
+ la_data_out[37] la_data_out[38] la_data_out[39] la_data_in[42] la_data_out[40] la_data_out[41]
+ la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45] la_data_out[46]
+ la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_oenb[46] la_oenb[38]
+ la_oenb[39] la_oenb[37] la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_oenb[44] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_oenb[26]
+ la_oenb[27] la_oenb[28] la_oenb[29] la_data_in[38] la_oenb[30] la_oenb[31] la_oenb[32]
+ la_oenb[33] la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[47] la_oenb[48] la_oenb[49]
+ la_oenb[50] la_oenb[51] la_oenb[52] la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56]
+ la_oenb[57] la_oenb[58] la_oenb[59] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63]
+ la_oenb[64] la_oenb[65] la_oenb[66] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54] la_data_in[55]
+ la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[60] la_data_in[61]
+ la_data_in[62] la_data_in[63] la_data_out[47] la_data_out[48] la_data_out[49] la_data_in[64]
+ la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_in[65] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_in[66] la_data_in[67] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_data_in[86] la_data_in[87] la_data_in[69] la_oenb[67] la_oenb[68]
+ la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75]
+ la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79] la_oenb[80] la_oenb[81] la_oenb[82]
+ la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86] la_oenb[87] la_data_out[68] la_data_out[69]
+ la_data_in[70] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_in[71] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_in[68] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[101] la_data_in[102] la_data_in[103]
+ la_data_in[104] la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108]
+ la_data_in[100] la_data_in[90] la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98] la_data_in[99] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[93] la_data_out[106] la_data_out[94] la_data_out[107] la_data_out[95]
+ la_data_out[96] la_data_out[108] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[92] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[88] la_data_in[89] la_data_out[88]
+ la_data_out[89] la_data_out[90] la_data_out[91] la_data_in[119] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_in[116] la_data_in[117] la_data_out[123]
+ la_data_in[112] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_data_in[118] la_oenb[109] la_data_in[120] la_oenb[110] la_data_in[121] la_oenb[111]
+ la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118]
+ la_oenb[119] la_data_in[122] la_data_in[123] la_oenb[120] la_oenb[121] la_oenb[122]
+ la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_out[110] user_clock2 user_irq[0]
+ la_data_in[113] user_irq[1] la_data_in[114] user_irq[2] la_data_out[111] la_data_out[112]
+ la_data_out[109] la_data_in[109] la_data_out[113] la_data_in[110] la_data_out[114]
+ la_oenb[108] la_data_out[115] la_data_out[116] la_data_in[111] la_data_out[117]
+ la_data_in[115] la_data_out[118] la_data_out[119] io_analog[4] io_analog[5] io_analog[6]
+ gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5] gpio_analog[6] gpio_noesd[2]
+ gpio_noesd[3] gpio_noesd[4] gpio_noesd[5] gpio_noesd[6] io_analog[0] io_analog[1]
+ io_analog[2] io_analog[3] io_clamp_high[0] io_clamp_low[0] io_in[10] io_in[11] io_in[12]
+ io_in[13] io_in[9] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12] io_in_3v3[13] io_in_3v3[9]
+ io_oeb[10] io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9] io_out[10] io_out[11] io_out[12]
+ io_out[13] io_out[9] vccd1 vdda1 io_in[16] io_in[17] gpio_analog[9] gpio_noesd[10]
+ io_analog[7] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_analog[8]
+ io_analog[9] gpio_noesd[7] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] gpio_noesd[8]
+ io_clamp_high[1] io_clamp_high[2] gpio_noesd[9] io_clamp_low[1] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10] vccd2 gpio_analog[7]
+ gpio_analog[8] io_in[14] io_in[15] io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] gpio_analog[16]
+ gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11] io_in[18] io_in[19]
+ io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23]
+ io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24] io_in[25] io_in[26]
+ gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] io_out[18] io_out[19]
+ io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25] io_out[26] gpio_noesd[16]
+ gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15] io_in_3v3[18] io_in_3v3[19]
+ vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23] vssd2 io_in_3v3[6]
+ io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0] io_in[2] io_in[3] io_in[4]
+ io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8] gpio_analog[0] io_oeb[1]
+ io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7] io_out[8]
+ gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4] io_oeb[2]
+ io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8] vssd1 io_in_3v3[5] io_out[0]
Xreram_0 io_analog[7] io_analog[1] io_analog[5] io_analog[4] io_analog[0] la_data_in[124]
+ la_data_in[35] vccd2 vssa2 la_data_in[25] vssa2 vssa2 io_analog[3] la_data_in[68]
+ vccd1 la_data_in[123] la_data_in[51] la_data_in[32] vccd1 vccd2 vccd1 vccd2 la_data_in[9]
+ vccd2 vccd1 la_data_in[84] vssa2 vccd1 io_analog[3] vccd1 la_data_in[48] io_analog[3]
+ vccd1 io_analog[3] reram_0/1T1R_midcell_0506_16x1_0[6]/1T1R_W1um_F4_layout_9/SL
+ vccd1 vdda2 io_analog[3] vdda2 vccd2 vccd1 gpio_analog[8] vssa2 vccd1 vssa2 vssa2
+ la_data_in[44] vccd1 io_analog[3] vssa2 gpio_analog[7] vccd2 vccd2 la_data_in[77]
+ la_data_in[24] vccd2 la_data_in[31] la_data_in[60] vccd2 vssa2 io_analog[3] la_data_in[40]
+ io_analog[3] vdda2 la_data_in[93] la_data_in[8] la_data_in[15] vccd2 vdda2 reram_0/1T1R_midcell_0506_16x1_0[8]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ la_data_in[56] io_analog[10] vssa2 reram_0/1T1R_midcell_0506_16x1_0[10]/1T1R_W1um_F4_layout_9/SL
+ vdda1 vssa2 io_analog[3] io_analog[3] io_analog[3] vdda2 la_data_in[89] vdda2 vdda1
+ vccd2 vccd2 vdda1 io_analog[3] vssa2 vssa2 vssa2 io_analog[3] la_data_in[23] vssa2
+ la_data_in[36] vccd2 vccd2 vssa2 vccd1 vccd2 vssa2 la_data_in[7] io_analog[3] la_data_in[69]
+ io_analog[3] la_data_in[52] vccd2 vdda1 vccd2 la_data_in[121] la_data_in[126] reram_0/MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1
+ io_analog[3] la_data_in[85] vssa2 vssa2 vdda2 vdda2 io_analog[3] reram_0/1T1R_midcell_0506_16x1_0[7]/1T1R_W1um_F4_layout_9/SL
+ gpio_analog[13] vdda2 la_data_in[120] io_analog[10] vssa2 vdda1 vccd2 vccd2 vssa2
+ la_data_in[45] vdda1 la_data_in[22] vdda2 vccd2 io_analog[3] io_analog[3] vdda2
+ vccd2 io_analog[3] reram_0/1T1R_midcell_0506_16x1_0[13]/1T1R_W1um_F4_layout_9/SL
+ la_data_in[65] la_data_in[78] la_data_in[61] la_data_in[6] io_analog[3] vdda1 vdda2
+ vssa2 la_data_in[41] vssa2 io_analog[3] vdda2 vssa2 la_data_in[81] la_data_in[94]
+ vssa2 vccd2 la_data_in[74] vdda1 vccd2 la_data_in[57] reram_0/1T1R_midcell_0506_16x1_0[8]/1T1R_W1um_F4_layout_9/SL
+ vccd1 vssa2 reram_0/MuxingToPadWithOPAMP_1/TG_8x1_MUX_HV_0/TG_2x1_MUX_HV_0/IN1 vccd2
+ vccd1 io_analog[3] vccd2 vdda2 la_data_in[90] vccd2 vdda2 io_analog[3] la_data_in[21]
+ vdda2 reram_0/1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/SL vdda1 vdda1 vssa2
+ io_analog[3] vdda2 io_analog[3] la_data_in[125] vdda2 reram_0/1T1R_midcell_0506_16x1_0[9]/1T1R_W1um_F4_layout_9/SL
+ vssa2 la_data_in[37] la_data_in[5] vccd2 vccd1 vssa2 vdda1 la_data_in[20] vssa2
+ vssa2 vdda1 reram_0/1T1R_midcell_0506_16x1_0[12]/1T1R_W1um_F4_layout_9/SL reram_0/1T1R_midcell_0506_16x1_0[5]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ vccd2 io_analog[3] la_data_in[53] reram_0/1T1R_midcell_0506_16x1_0[12]/1T1R_W1um_F4_layout_9/SL
+ reram_0/1T1R_midcell_0506_16x1_0[13]/1T1R_W1um_F4_layout_9/SL vdda1 vdda2 vccd2
+ la_data_in[4] vccd2 la_data_in[30] la_data_in[86] vdda2 vdda1 vdda1 vssa2 io_analog[3]
+ vccd1 vdda2 io_analog[3] vdda2 vccd1 vdda2 la_data_in[14] vccd1 vccd2 vccd1 vssa2
+ vssa2 vccd1 la_data_in[33] la_data_in[46] io_analog[3] vdda1 vdda1 reram_0/1T1R_midcell_0506_16x1_0[7]/1T1R_W1um_F4_layout_9/SL
+ vdda1 vdda1 vccd2 la_data_in[19] vdda1 la_data_in[79] la_data_in[66] vccd1 vccd2
+ la_data_in[49] vccd1 la_data_in[62] la_data_in[127] vssa2 vccd1 la_data_in[122]
+ la_data_in[42] io_analog[3] io_analog[6] vdda2 la_data_in[3] la_data_in[95] la_data_in[82]
+ vdda2 vccd2 la_data_in[29] la_data_in[121] gpio_analog[9] la_data_in[58] vccd1 vssa2
+ io_analog[3] vdda2 la_data_in[120] la_data_in[13] vdda2 io_analog[3] io_analog[8]
+ vccd2 vdda1 vdda1 vssa2 la_data_in[124] la_data_in[75] vssa2 vdda1 io_analog[3]
+ la_data_in[18] vdda1 vdda1 la_data_in[38] vccd2 la_data_in[123] vdda1 la_data_in[91]
+ vccd1 vccd2 la_data_in[2] vssa2 io_analog[3] reram_0/1T1R_midcell_0506_16x1_0[6]/1T1R_topcell_04_06_0/VLS_1v8to5V_D1_And_VoltSelector_Layout_1/DATA_IN_LV_1
+ la_data_in[54] la_data_in[28] io_analog[3] vdda2 io_analog[3] vdda2 vccd2 vssa2
+ la_data_in[87] la_data_in[12] vdda1 vssa2 vdda2 vdda1 vssa2 vdda1 vccd2 vccd1 vdda2
+ vdda1 vccd1 vccd2 vccd2 vccd1 vdda1 la_data_in[47] la_data_in[34] la_data_in[17]
+ vccd1 vccd1 vdda1 io_analog[3] vccd1 vdda2 vccd1 vdda1 vccd1 io_analog[3] vdda1
+ io_analog[3] vccd1 vccd1 vdda2 la_data_in[67] vdda2 vdda2 vccd1 la_data_in[50] la_data_in[1]
+ vccd1 la_data_in[63] reram_0/1T1R_midcell_0506_16x1_0[14]/1T1R_W1um_F4_layout_9/SL
+ vccd1 vccd1 la_data_in[27] vdda1 vssa2 vdda1 vccd1 vssa2 vssa2 vccd1 la_data_in[64]
+ la_data_in[83] vccd1 io_analog[3] vdda1 la_data_in[11] vdda1 vccd1 vccd2 reram_0/1T1R_midcell_0506_16x1_0[11]/1T1R_W1um_F4_layout_9/SL
+ reram_0/1T1R_midcell_0506_16x1_0[11]/1T1R_W1um_F4_layout_9/SL vccd1 vccd1 vccd2
+ reram_0/1T1R_midcell_0506_16x1_0[8]/1T1R_W1um_F4_layout_9/SL vccd2 gpio_analog[10]
+ la_data_in[80] vdda1 vssa2 vdda1 vdda2 vdda1 vdda2 vdda2 la_data_in[43] io_analog[3]
+ vccd1 vdda2 la_data_in[16] vdda1 vdda2 vdda1 vccd2 la_data_in[76] la_data_in[59]
+ vssa2 gpio_analog[7] vdda2 vdda2 la_data_in[0] la_data_in[39] io_analog[3] io_analog[3]
+ la_data_in[26] vdda2 la_data_in[92] gpio_analog[11] vccd1 vdda1 vccd2 vdda1 vdda1
+ la_data_in[72] la_data_in[55] vdda1 vdda1 vssa2 vssa2 vccd1 la_data_in[10] io_analog[3]
+ vdda1 vdda2 gpio_analog[14] la_data_in[88] vccd2 vccd2 vdda2 vdda2 reram_0/1T1R_midcell_0506_16x1_0[10]/1T1R_W1um_F4_layout_9/SL
+ reram_0/1T1R_midcell_0506_16x1_0[14]/1T1R_W1um_F4_layout_9/SL vssa2 io_analog[9]
+ vdda1 io_analog[3] vdda1 vdda1 io_analog[3] vdda2 io_analog[3] vdda2 vssa2 gpio_analog[12]
+ reram
R0 io_oeb[15] m3_780_462398# sky130_fd_pr__res_generic_m3 w=560000u l=600000u
R1 m3_573405_455628# io_oeb[11] sky130_fd_pr__res_generic_m3 w=560000u l=580000u
R2 io_oeb[16] m3_738_419176# sky130_fd_pr__res_generic_m3 w=560000u l=310000u
R3 m3_573371_500050# io_oeb[12] sky130_fd_pr__res_generic_m3 w=560000u l=490000u
.ends
